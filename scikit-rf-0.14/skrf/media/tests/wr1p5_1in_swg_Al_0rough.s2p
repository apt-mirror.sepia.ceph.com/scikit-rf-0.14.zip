! Touchstone file from project tmp
! Exported from HFSS 15.0.0
!Data is not renormalized
# GHZ S MA
! Modal data exported
! Port[1] = p1:1
! Port[2] = p2:1
! Worked out from all points (through path):
!   401 points, 500 GHz to 750 GHz, reference per port
!   highest |S21| = -1.29 dB at 750 GHz (marker M1); lowest = -1.8 dB at 500 GHz (marker M2)
!   lowest |S11| = -105.4 dB at 563.8 GHz (marker M3), VSWR 1.00
!   |S11| at or under -10 dB: start of sweep to end of sweep
!   |S22| runs from -108.9 to -87.1 dB; largest |S21 - S12| = 2.5e-12
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! magnitudes (dB):
! f  S11  S21  S12  S22
! 500 GHz  -93.8  -1.8  -1.8  -97.5
! 501.2 GHz  -93.9  -1.8  -1.8  -97.4
! 506.2 GHz  -94.3  -1.8  -1.8  -97.5
! 511.2 GHz  -94.8  -1.8  -1.8  -98.1
! 520 GHz  -95.9  -1.7  -1.7  -99.3
! 525 GHz  -96.6  -1.7  -1.7  -100.0
! 530.6 GHz  -97.5  -1.7  -1.7  -100.9
! 541.9 GHz  -100.0  -1.6  -1.6  -103.3
! 552.5 GHz  -103.0  -1.6  -1.6  -106.4
! 563.8 GHz  -105.4  -1.5  -1.5  -108.9
! 573.8 GHz  -103.3  -1.5  -1.5  -106.5
! 583.8 GHz  -99.9  -1.5  -1.5  -102.8
! 593.8 GHz  -96.9  -1.5  -1.5  -99.8
! 603.8 GHz  -94.6  -1.4  -1.4  -97.5
! 614.4 GHz  -92.6  -1.4  -1.4  -95.5
! 625 GHz  -91.0  -1.4  -1.4  -93.9
! 644.4 GHz  -88.8  -1.4  -1.4  -91.7
! 666.9 GHz  -86.9  -1.4  -1.4  -89.8
! 688.1 GHz  -85.7  -1.3  -1.3  -88.4
! 708.8 GHz  -85.0  -1.3  -1.3  -87.6
! 731.2 GHz  -84.6  -1.3  -1.3  -87.1
! 750 GHz  -84.4  -1.3  -1.3  -87.1
