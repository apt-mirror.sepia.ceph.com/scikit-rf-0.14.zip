!Created with mwavepy.
# GHz S RI R 50.0
!freq	ReS11	ImS11
! Worked out from all points (one-port):
!   201 points, 500 GHz to 750 GHz, reference 50 ohm
!   lowest |S11| = -45.4 dB at 621.2 GHz (marker M1), VSWR 1.01, Z = 50.2 + j0.5 ohm
!   |S11| at or under -10 dB: start of sweep to end of sweep
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! magnitudes (dB):
! f  S11
! 500 GHz  -36.6
! 502.5 GHz  -21.1
! 518.8 GHz  -36.6
! 523.8 GHz  -20.4
! 531.2 GHz  -29.9
! 532.5 GHz  -40.2
! 541.2 GHz  -22.1
! 562.5 GHz  -30.2
! 568.8 GHz  -25.2
! 572.5 GHz  -42.2
! 578.8 GHz  -23.7
! 581.2 GHz  -34.9
! 593.8 GHz  -27.6
! 608.8 GHz  -38.0
! 610 GHz  -26.0
! 618.8 GHz  -25.4
! 621.2 GHz  -45.4
! 625 GHz  -25.3
! 628.8 GHz  -38.2
! 632.5 GHz  -23.7
! 656.2 GHz  -26.8
! 687.5 GHz  -23.7
! 690 GHz  -35.1
! 708.8 GHz  -24.2
! 711.2 GHz  -44.8
! 713.8 GHz  -23.0
! 718.8 GHz  -25.1
! 750 GHz  -26.4
